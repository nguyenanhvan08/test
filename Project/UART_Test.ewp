# IAR project UART_Test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: C:\Users\TAN\Desktop\STM8L_TestUART\Libraries\inc; C:\Users\TAN\Desktop\STM8L_TestUART\User; C:\Users\TAN\Desktop\STM8L_TestUART\Project\My_inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_Test.hex
  ILINK.IlinkOutputFile: UART_Test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Libraries
    ../Libraries/src/: stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_tim4.c stm8l15x_usart.c
  group User
    ../User/: main.c stm8l15x_it.c stm8l15x_it.h
